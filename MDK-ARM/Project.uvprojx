# Keil uVision project Project.uvprojx, settings and files
target EVB_32F03x_START (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: CS32F030C8T6 Chipsea
  pack: Chipsea.CS32F03x_DFP.2.0.5
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: CS32F030_Pro +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: CS32F0XX,
  c include: ..\Device\HAL_Driver\inc;..\Device\Include;..\User\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group User
    ../User/Src/: cs32f0xx_int.c sys.c main.c gpio.c timer.c uart.c iic.c adc.c application.c
software components: CMSIS:CORE 5.0.1, Device:HAL:ADC 1.0.0, Device:HAL:CRC 1.0.0, Device:HAL:DEBUG 1.0.0, Device:HAL:DMA 1.0.0, Device:HAL:EXTI 1.0.0, Device:HAL:FWDT 1.0.0, Device:HAL:Flash 1.0.0, Device:HAL:Framework 1.0.0, Device:HAL:GPIO 1.0.0, Device:HAL:I2C 1.0.0, Device:HAL:PMU 1.0.0, Device:HAL:RCU 1.0.0, Device:HAL:RTC 1.0.0, Device:HAL:SPI 1.0.0, Device:HAL:SYSCFG 1.0.0, Device:HAL:TIM 1.0.0, Device:HAL:USART 1.0.0, Device:HAL:WWDT 1.0.0, Device:Startup 1.0.0
